# Repository afay2017/GEMS-BOARDS

## EAGLE design ElectronBoardMKII.brd

Parts:
12V: SMKDSP_1,5/2
BIAS: 10k; CT6
C1, C7: 10uf; E5-8,5
C2, C4, C9: 1uf; E5-8,5
C3: 220uf; E5-8,5
C8: 0.047uf; C050-035X075
FAN: SMKDSP_1,5/2
GAIN: 10k; CT6
IC1: 7805TV; TO220V
IN-TEMP: CONN_03LOCK_LONGPADS; 1X03_LOCK_LONGPADS
J1: CONN_08LOCK_LONGPADS; 1X08_LOCK_LONGPADS
J2, J3, J4, J6: CONN_09LOCK; 1X09_LOCK
J5, J7: J2X2MM; 04C
K1: AQYAQY27; AQY27
LED1, LED2, LED3, LED4: CONN_02LOCK_LONGPADS; 1X02_LOCK_LONGPADS
LEDOUT: SMKDSP_1,5/2
OUT-TEMP: CONN_03LOCK_LONGPADS; 1X03_LOCK_LONGPADS
PUMP: SMKDSP_1,5/2
Q1, Q2: BSS170; TO92
R1, R3, R12, R13, R14, R15: 4.7k; 0207/12
R2, R4, R5, R6, R7: R-US_0207/10; 0207/10
R9: 100k; 0207/5V
R16, R17: 47k; 0207/12
R19: 10k; 0207/12
RX_______TX: CONN_02LOCK_LONGPADS; 1X02_LOCK_LONGPADS
SCL___SDA1, SCL___SDA2: CONN_02LOCK_LONGPADS; 1X02_LOCK_LONGPADS
SCREEN: CONN_05X2SHD; 2X5-SHROUDED
SPEAKER: SMKDSP_1,5/2
U1: LM386N; DIP08
U$1: ELECTRON_WITH_HEADERS; ELECTRON
U$2: VNH5019VNH5019BOARD; DIP3302W60P254L2400H500Q20B
VIN: SMKDSP_1,5/2
VOLUME: 10k; CT6

Connections:
3V3: BIAS.E, IN-TEMP.3, J3.1, OUT-TEMP.3, Q1.2 (G), Q2.2 (G), R1.2, R3.2, R12.2, R14.2, SCREEN.6, U$1.36 (3V3), U$2.VDD
5V: C2.+, IC1.3 (VO), J5.1, R13.2, R15.2
+12V: 12V.1, U$2.VIN1, U$2.VIN2
A2: J6.1, U$1.10 (A2)
A4: J2.8, U$1.8 (A4)
COOLING-CURRENT: J2.9, U$1.9 (A3), U$2.CS
COOLING-INA: J4.1, R16.1, U$1.27 (D2), U$2.INA
COOLING-INB: J3.8, R17.2, U$1.29 (D4), U$2.INB
COOLING-OUTA: FAN.2, PUMP.2, U$2.OUTA1, U$2.OUTA2
COOLING-OUTB: FAN.1, PUMP.1, U$2.OUTB1, U$2.OUTB2
COOLING-PWM: J3.9, U$1.28 (D3), U$2.PWM
D5: J3.7, U$1.30 (D5)
D6: J3.6, U$1.31 (D6)
D7: J3.5, U$1.32 (D7)
DAC: J2.6, J7.3, U$1.6 (DAC)
GND: 12V.2, BIAS.A, C1.-, C2.-, C9.-, IC1.2 (GND), IN-TEMP.1, J2.2, J3.4, LED1.1, LED2.1, LED3.1, LED4.1, LEDOUT.1, OUT-TEMP.1, R7.1, R16.2, R17.1, R19.1, SCREEN.3, SCREEN.4, SCREEN.8, SCREEN.10, SPEAKER.2, U1.3 (+IN), U1.4 (V-), U$1.2 (GND), U$1.33 (GND), U$2.GND1, U$2.GND2, U$2.GND3, U$2.GND4, VIN.2, VOLUME.A
IN-TEMP: IN-TEMP.2, J2.7, U$1.7 (A5)
KEYPAD-1: J1.3, J6.5, U$1.14 (B4)
KEYPAD-2: J1.4, J6.6, U$1.15 (B3)
KEYPAD-3: J1.5, J6.7, U$1.16 (B2)
KEYPAD-A: J1.1, J6.3, U$1.12 (A0)
KEYPAD-B: J1.2, J6.4, U$1.13 (B5)
KEYPAD-C: J1.8, J6.9, U$1.18 (B0)
KEYPAD-D: J1.7, J6.8, U$1.17 (B1)
LIGHTS: J4.9, K1.1 (A), U$1.19 (C0)
unnamed: C4.+, R9.1, U1.2 (-IN)
unnamed: C9.+, U1.7 (BP)
unnamed: LED4.2, R6.1
unnamed: GAIN.A, U1.1 (GAIN)
unnamed: C7.-, U1.8 (GAIN)
unnamed: C3.+, C8.1, U1.5 (OUT)
unnamed: C8.2, R19.2
unnamed: K1.2 (K), R7.2
unnamed: C7.+, GAIN.S
unnamed: J5.2, K1.4 (DS1)
unnamed: K1.3 (DS2), LEDOUT.2, R2.2, R4.2, R5.2, R6.2
unnamed: LED1.2, R2.1
unnamed: LED2.2, R4.1
unnamed: C4.-, VOLUME.S
unnamed: LED3.2, R5.1
unnamed: BIAS.S, R9.2
OUT-TEMP: J6.2, OUT-TEMP.2, U$1.11 (A1)
RST: J3.2, U$1.35 (!RST)
RX: J2.4, RX_______TX.1, U$1.4 (RX)
SCL-3V3: J4.2, Q1.1 (S), R12.1, U$1.26 (D1)
SCL-5V: Q1.3 (D), R13.1, SCL___SDA1.2, SCL___SDA2.2
SCREEN-BLUE-CONTROL: J4.6, SCREEN.5, U$1.22 (C3)
SCREEN-GREEN-CONTROL: J4.7, SCREEN.7, U$1.21 (C2)
SCREEN-RED-CONTROL: J4.8, SCREEN.9, U$1.20 (C1)
SCREEN-SCL: J4.4, R1.1, SCREEN.1, U$1.24 (C5)
SCREEN-SDA: J4.5, R3.1, SCREEN.2, U$1.23 (C4)
SDA-3V3: J4.3, Q2.1 (S), R14.1, U$1.25 (D0)
SDA-5V: Q2.3 (D), R15.1, SCL___SDA1.1, SCL___SDA2.1
SOUND: J7.2, VOLUME.E
SPEAKER-OUTPUT: C3.-, SPEAKER.1
TX: J2.3, RX_______TX.2, U$1.3 (TX)
VBAT: J3.3, U$1.34 (VBAT)
VIN: C1.+, IC1.1 (VI), J2.1, J5.3, U1.6 (V+), U$1.1 (VIN), VIN.1
WKP: J2.5, J7.1, U$1.5 (WKP)

Notes on the sheet:
Audio Power Amplifier with Controlled Gain
Potentiometer R1 act as volume control knob
4V-12V
R2 and C2 act as filter to remove sudden High frequency oscillations
Gain sets the range of possible volume levels
Gain = 30000/(150+R3)
Gain = 20 - 200
R3 = 150+(30000/Gain)
Useful Notes
By varying R3 across pin 1 and 8, Gain can be varied from 20 to 200
Example, if Gain is 20, then volume range is 0 to 20
If gain is 200 then range volume range extends from 0 to 200

Board: 2 copper layers, 84.0 x 200.0 mm, 59 parts (0 on the bottom side), 59 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: 4,1

## EAGLE design ArduinoBoardMKII.brd

Parts:
12V: SMKDSP_1,5/2
CPC1718: CPC1708J; I4-PAC
GND: CONN_01; 1X01
J1, J4: CONN_10LOCK; 1X10_LOCK
J2, J3: CONN_07LOCK; 1X07_LOCK
J6: CONN_021X02_NO_SILK; 1X02_NO_SILK
JP1, JP2: JP2E; JP2
LED1: LED-DIP-3; DIP-4
MICRO: ARDUINO_MICROFOOTPRINT; ARDUINO-MICRO
MOTOR1: SMKDSP_1,5/2
PELTIER1: SMKDSP_1,5/2
R1, R2: 220; 0207/10
R3: 330; 0207/10
R4, R5: 47k; 0207/10
R6, R9: 47k; 0207/12
R7, R8: 1k; 0207/12
R10: 1k; 0207/7
R11: 4.7k; 0207/10
SDA__SCL1, SDA__SCL2: CONN_02PTH3; 1X02_LONGPADS
SG1: F/QMB
SWITCH: CONN_02PTH3; 1X02_LONGPADS
T1: 2N2222; TO18
TEMPERATURE1, TEMPERATURE2: CONN_03LONGPADS; 1X03_LONGPADS
TLE5205: TLE5205-2; P-TO220-7-11
VIN: SMKDSP_1,5/2
VNH5019: VNH5019VNH5019BOARD; DIP3302W60P254L2400H500Q20B

Connections:
3V3: J3.6, MICRO.3V3 (3V), TEMPERATURE1.3, TEMPERATURE2.3
+5V: J4.6, J6.2, JP1.1, JP2.1, MICRO.5V, SG1.+ (-), SWITCH.2, VNH5019.VDD
+12V: 12V.1, CPC1718.1 (DS1), VNH5019.VIN1, VNH5019.VIN2
BUZZER: J3.7, MICRO.D13 (IO13*), R10.1
DOORSWITCH: J3.2, MICRO.A2, R11.1, SWITCH.1
GND: 12V.2, GND.1, J1.6, J4.4, JP1.3, JP2.3, LED1.COMMON_CATHODE (COM-CATHODE), MICRO.GND, MICRO.GND1, R3.1, R4.2, R5.1, R11.2, T1.1 (E), TEMPERATURE1.1, TEMPERATURE2.1, TLE5205.4 (GND), VIN.2, VNH5019.GND1, VNH5019.GND2, VNH5019.GND3, VNH5019.GND4
IN1: R8.2, TLE5205.3 (IN1)
IN2: R7.2, TLE5205.5 (IN2)
MOTOR-ENABLE: CPC1718.4 (A), J2.4, MICRO.D9 (IO9*)
MOTOR-ERRORFLAG: J2.7, MICRO.D12 (IO12*), TLE5205.2 (EF)
MOTOR-IN1: J2.5, MICRO.D10 (IO10*), R8.1, R9.1
MOTOR-IN2: J2.6, MICRO.D11 (IO11*), R6.1, R7.1
MOTOR-OUT1: MOTOR1.1, TLE5205.1 (OUT1)
MOTOR-OUT2: MOTOR1.2, TLE5205.7 (OUT2)
unnamed: LED1.BLUE, R2.2
unnamed: LED1.GREEN, R1.2
unnamed: JP1.2, R6.2
unnamed: J1.5, MICRO.RST (RESET)
unnamed: J1.4, MICRO.RX (D0/RX)
unnamed: J1.3, MICRO.TX (D1/TX)
unnamed: J1.2, MICRO.SS (RXLED/SS)
unnamed: J1.1, MICRO.MOSI
unnamed: J3.1, MICRO.A3
unnamed: JP2.2, R9.2
unnamed: J6.1, SG1.- (+), T1.3 (C)
unnamed: J3.4, MICRO.A0
unnamed: J3.5, MICRO.REF (AREF)
unnamed: R10.2, T1.2 (B)
unnamed: J4.10, MICRO.A4
unnamed: J4.5, MICRO.RST1 (RESET1)
unnamed: J4.8, MICRO.NC8
unnamed: J4.7, MICRO.NC7
unnamed: J4.2, MICRO.MISO
unnamed: J4.1, MICRO.SCK
PELTIER-CURRENT: VNH5019.CS
PELTIER-INA: J2.1, MICRO.D6 (D6*), R4.1, VNH5019.INA
PELTIER-INB: J1.9, MICRO.D4 (D4*), R5.2, VNH5019.INB
PELTIER-OUTA: PELTIER1.2, VNH5019.OUTA1, VNH5019.OUTA2
PELTIER-OUTB: PELTIER1.1, VNH5019.OUTB1, VNH5019.OUTB2
PELTIER-PWM: J1.10, MICRO.D5 (D5*), VNH5019.PWM
POST-OPTO-DIODE: CPC1718.3 (K), R3.2
RELAY-TO-MOTORCONTROLLER: CPC1718.2 (DS2), TLE5205.6 (VS)
RGBD-BLUE: J2.3, MICRO.D8 (IO8), R2.1
RGBD-GREEN: J2.2, MICRO.D7, R1.1
SCL: J1.8, MICRO.D3 (D3/SCL), SDA__SCL1.2, SDA__SCL2.2
SDA: J1.7, MICRO.D2 (D2/SDA), SDA__SCL1.1, SDA__SCL2.1
TEMPERATURE1: J3.3, MICRO.A1, TEMPERATURE1.2
TEMPERATURE2: J4.9, MICRO.A5, TEMPERATURE2.2
VIN: J4.3, MICRO.VIN, VIN.1

Notes on the sheet:
4 and 12 may not have PWM

Board: 2 copper layers, 95.2 x 82.5 mm, 35 parts (0 on the bottom side), 48 nets.

## EAGLE design ElectronBoardMKI.brd

Parts:
12V: SMKDSP_1,5/2
C1, C7: 10uf; E5-8,5
C2, C9: 1uf; E5-8,5
C3: 220uf; E5-8,5
C8: 0.047uf; C050-035X075
FAN: SMKDSP_1,5/2
IC1: 7805TV; TO220V
IN-TEMP: CONN_03LOCK_LONGPADS; 1X03_LOCK_LONGPADS
J1: CONN_08LOCK_LONGPADS; 1X08_LOCK_LONGPADS
OUT-TEMP: CONN_03LOCK_LONGPADS; 1X03_LOCK_LONGPADS
PUMP: SMKDSP_1,5/2
Q1, Q2: BSS170; TO92
R1, R3, R12, R13, R14, R15: 4.7k; 0207/12
R16, R17: 47k; 0207/12
R19: 10k; 0207/12
R21, R22: 10k; CT6
RX_______TX: CONN_02LOCK_LONGPADS; 1X02_LOCK_LONGPADS
SCL___SDA1, SCL___SDA2: CONN_02LOCK_LONGPADS; 1X02_LOCK_LONGPADS
SCREEN: CONN_05X2SHD; 2X5-SHROUDED
SPEAKER: SMKDSP_1,5/2
U1: LM386N; DIP08
U$1: ELECTRON_WITH_HEADERS; ELECTRON
U$2: VNH5019VNH5019BOARD; DIP3302W60P254L2400H500Q20B
VIN: SMKDSP_1,5/2

Connections:
3V3: IN-TEMP.3, OUT-TEMP.3, Q1.2 (G), Q2.2 (G), R1.2, R3.2, R12.2, R14.2, SCREEN.6, U$1.36 (3V3), U$2.VDD
5V: C2.+, IC1.3 (VO), R13.2, R15.2
+12V: 12V.1, U$2.VIN1, U$2.VIN2
COOLING-CURRENT: U$1.9 (A3), U$2.CS
COOLING-INA: R16.1, U$1.27 (D2), U$2.INA
COOLING-INB: R17.2, U$1.29 (D4), U$2.INB
COOLING-OUTA: FAN.2, PUMP.2, U$2.OUTA1, U$2.OUTA2
COOLING-OUTB: FAN.1, PUMP.1, U$2.OUTB1, U$2.OUTB2
COOLING-PWM: U$1.28 (D3), U$2.PWM
GND: 12V.2, C1.-, C2.-, C9.-, IC1.2 (GND), IN-TEMP.1, OUT-TEMP.1, R16.2, R17.1, R19.1, R21.A, SCREEN.3, SCREEN.4, SCREEN.8, SCREEN.10, SPEAKER.2, U1.3 (+IN), U1.4 (V-), U$1.2 (GND), U$1.33 (GND), U$2.GND1, U$2.GND2, U$2.GND3, U$2.GND4, VIN.2
IN-TEMP: IN-TEMP.2, U$1.6 (DAC)
KEYPAD-1: J1.3, U$1.14 (B4)
KEYPAD-2: J1.4, U$1.15 (B3)
KEYPAD-3: J1.5, U$1.16 (B2)
KEYPAD-A: J1.1, U$1.12 (A0)
KEYPAD-B: J1.2, U$1.13 (B5)
KEYPAD-C: J1.8, U$1.18 (B0)
KEYPAD-D: J1.7, U$1.17 (B1)
unnamed: R21.S, U1.2 (-IN)
unnamed: C9.+, U1.7 (BP)
unnamed: R22.A, U1.1 (GAIN)
unnamed: C7.-, U1.8 (GAIN)
unnamed: C3.+, C8.1, U1.5 (OUT)
unnamed: C8.2, R19.2
unnamed: C7.+, R22.S
OUT-TEMP: OUT-TEMP.2, U$1.11 (A1)
RX: RX_______TX.1, U$1.4 (RX)
SCL-3V3: Q1.1 (S), R12.1, U$1.26 (D1)
SCL-5V: Q1.3 (D), R13.1, SCL___SDA1.2, SCL___SDA2.2
SCREEN-BLUE-CONTROL: SCREEN.5, U$1.22 (C3)
SCREEN-GREEN-CONTROL: SCREEN.7, U$1.21 (C2)
SCREEN-RED-CONTROL: SCREEN.9, U$1.20 (C1)
SCREEN-SCL: R1.1, SCREEN.1, U$1.24 (C5)
SCREEN-SDA: R3.1, SCREEN.2, U$1.23 (C4)
SDA-3V3: Q2.1 (S), R14.1, U$1.25 (D0)
SDA-5V: Q2.3 (D), R15.1, SCL___SDA1.1, SCL___SDA2.1
SOUND: R21.E, U$1.5 (WKP)
SPEAKER-OUTPUT: C3.-, SPEAKER.1
TX: RX_______TX.2, U$1.3 (TX)
VBAT: U$1.34 (VBAT)
VIN: C1.+, IC1.1 (VI), U1.6 (V+), U$1.1 (VIN), VIN.1

Notes on the sheet:
Audio Power Amplifier with Controlled Gain
Potentiometer R1 act as volume control knob
4V-12V
R2 and C2 act as filter to remove sudden High frequency oscillations
Gain sets the range of possible volume levels
Gain = 30000/(150+R3)
Gain = 20 - 200
R3 = 150+(30000/Gain)
Useful Notes
By varying R3 across pin 1 and 8, Gain can be varied from 20 to 200
Example, if Gain is 20, then volume range is 0 to 20
If gain is 200 then range volume range extends from 0 to 200

Board: 2 copper layers, 84.0 x 200.0 mm, 39 parts (0 on the bottom side), 40 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: 4,1

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
Particle-Devices: Licensing: Designed by Particle.
