# Repository afay2017/GEMS-BOARDS (continued)

## EAGLE design Legacy/gems-0-01.brd

Parts:
C1, C2: .1uF; C025-025X050
J1, J2: CONN_05X2SHD-NS; 2X5-SHROUDED-NS
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8: SCREW-TERMINAL-2PIN-5MM-KEYED; SCREWTERMINAL-5MM-2-DIAG
R1, R2, R3: 4.7K; 0204/5
U1: ADA-KEYPAD-HDR; HDR-7-STAGGERED
U3: ELECTRON
U4: NHD‐C0220; NHD-C0220
U5, U6, U7, U8: VNH5019-POLOLU; VNH1519-CARRIER
U9, U10, U11, U12: TMP36; JST-3-PTH

Connections:
3V3_S: J2.6, U4.1 (RST), U4.5 (VDD), U4.A
+3V3: J1.6, JP7.F, R2.1, R3.1, U3.19 (3V3), U5.4 (VDD), U6.4 (VDD), U7.4 (VDD), U8.4 (VDD), U9.2 (VCC), U10.2 (VCC), U11.2 (VCC), U12.2 (VCC)
+12V: JP2.F, U5.17 (VIN), U5.18 (VIN), U6.17 (VIN), U6.18 (VIN), U7.17 (VIN), U7.18 (VIN), U8.17 (VIN), U8.18 (VIN)
C1_S: J2.9, U4.RK (K-R)
C2_S: J2.7, U4.GK (K-G)
C3_S: J2.5, U4.BK (K-B)
COL1: U1.5 (C1), U3.7 (A0)
COL2: U1.6 (C2), U3.8 (A1)
COL3: U1.7 (C3), U3.30 (D0)
DOOR_INA: U3.26 (D4), U6.10 (INA)
DOOR_INB: U3.27 (D3), U6.5 (INB)
DOOR_PWM: U3.2 (B1), U6.8 (PWM)
FAN_INA: U3.28 (D2), U7.8 (PWM), U7.10 (INA)
GND: J1.3, J1.4, J1.8, J1.10, JP1.M, JP2.M, JP8.M, R1.1, U3.17 (GND), U3.22 (GND), U5.1 (GND), U5.3 (GND), U5.15 (GND), U5.16 (GND), U6.1 (GND), U6.3 (GND), U6.15 (GND), U6.16 (GND), U7.1 (GND), U7.3 (GND), U7.5 (INB), U7.15 (GND), U7.16 (GND), U8.1 (GND), U8.3 (GND), U8.5 (INB), U8.15 (GND), U8.16 (GND), U9.1 (GND), U10.1 (GND), U11.1 (GND), U12.1 (GND)
GND_S: C2.1, J2.3, J2.4, J2.8, J2.10, U4.4 (VSS)
unnamed: JP3.F, U5.11 (OUTA), U5.12 (OUTA)
unnamed: JP3.M, U5.13 (OUTB), U5.14 (OUTB)
unnamed: U3.12 (A5), U9.3 (VOUT)
unnamed: U3.11 (A4), U10.3 (VOUT)
unnamed: U3.10 (A3), U11.3 (VOUT)
unnamed: JP4.F, U6.11 (OUTA), U6.12 (OUTA)
unnamed: JP4.M, U6.13 (OUTB), U6.14 (OUTB)
unnamed: JP5.F, U7.11 (OUTA), U7.12 (OUTA)
unnamed: JP5.M, U7.13 (OUTB), U7.14 (OUTB)
unnamed: JP6.F, U8.11 (OUTA), U8.12 (OUTA)
unnamed: JP6.M, U8.13 (OUTB), U8.14 (OUTB)
unnamed: U3.9 (A2), U12.3 (VOUT)
unnamed: JP7.M, R1.2, U3.36 (C0)
unnamed: JP8.F, U3.14 (WKP)
unnamed: C1.1, U4.8 (C1-)
unnamed: C1.2, U4.7 (C1+)
unnamed: C2.2, U4.6 (VOUT)
unnamed: J1.9, U3.35 (C1)
unnamed: J1.7, U3.34 (C2)
unnamed: J1.5, U3.33 (C3)
PELT_INA: U3.24 (D6), U5.10 (INA)
PELT_INB: U3.25 (D5), U5.5 (INB)
PELT_PWM: U3.1 (B0), U5.8 (PWM)
PUMP_INA: U3.29 (D1), U8.8 (PWM), U8.10 (INA)
ROW1: U1.1 (R1), U3.3 (B2)
ROW2: U1.2 (R2), U3.4 (B3)
ROW3: U1.3 (R3), U3.5 (B4)
ROW4: U1.4 (R4), U3.6 (B5)
SCL: J1.1, R2.2, U3.31 (C5)
SCL_S: J2.1, U4.2 (SCL)
SDA: J1.2, R3.2, U3.32 (C4)
SDA_S: J2.2, U4.3 (SDA)
VIN: JP1.F, U3.18 (VIN)

Notes on the sheet:
POWER TERMINALS
FAN
PELTIER
LOCK
PUMP
TEMP SENSORS VIA JST
KEYPAD
2X5 RIBBON
DISPLAY BREAKOUT BOARD
A. MCNICOLL 2/3/2017
SPEAKER

Board: 2 copper layers, 84.0 x 177.5 mm, 33 parts (1 on the bottom side), 48 nets.

Other parts of the board:
U$1, U$2, U$6, U$7: 4,1
U$3, U$4, U$5: SUPPORT_TAB_100MIL

## EAGLE design ArduinoBoardMK1.brd

Board: 2 copper layers, 95.2 x 82.5 mm, 22 parts (0 on the bottom side), 25 nets.

Parts:
12V: SMKDSP_1,5/2
GND: 1X01
K1: AQH2223; DIL07
MICRO: ARDUINO_MICROFOOTPRINT; ARDUINO-MICRO
MOTOR1: SMKDSP_1,5/2
PELTIER1: SMKDSP_1,5/2
R1: 220; 0207/12
R3: 4.7k; 0207/12
R6, R9, R10, R11: 47k; 0207/12
R7, R8: 1k; 0207/12
SDA__SCL1, SDA__SCL2: 1X02_LONGPADS
SWITCH: 1X02_LONGPADS
TEMPERATURE1, TEMPERATURE2: 1X03_LONGPADS
TLE5205: TLE5205-2; P-TO220-7-11
VIN: SMKDSP_1,5/2
VNH5019: VNH5019VNH5019BOARD; DIP3302W60P254L2400H500Q20B

Connections:
+5V: MICRO.5V, R9.2, SWITCH.2, TEMPERATURE1.3, TEMPERATURE2.3, VNH5019.VDD
+12V: 12V.1, K1.8, VNH5019.VIN1, VNH5019.VIN2
DOORSWITCH: MICRO.A2, R3.1, SWITCH.1
GND: 12V.2, MICRO.GND, MICRO.GND1, R1.1, R3.2, R6.1, R10.1, R11.2, TEMPERATURE1.1, TEMPERATURE2.1, TLE5205.4, VIN.2, VNH5019.GND1, VNH5019.GND2, VNH5019.GND3, VNH5019.GND4
IN1: R7.2, TLE5205.3
IN2: R8.2, TLE5205.5
MOTOR-ENABLE: K1.2, MICRO.D9
MOTOR-ERRORFLAG: MICRO.D12, TLE5205.2
MOTOR-IN1: MICRO.D10, R7.1, R9.1
MOTOR-IN2: MICRO.D11, R8.1, R10.2
MOTOR-OUT1: MOTOR1.1, TLE5205.1
MOTOR-OUT2: MOTOR1.2, TLE5205.7
PELTIER-CURRENT: MICRO.A0, VNH5019.CS
PELTIER-INA: MICRO.D6, R11.1, VNH5019.INA
PELTIER-INB: MICRO.D4, R6.2, VNH5019.INB
PELTIER-OUTA: PELTIER1.2, VNH5019.OUTA1, VNH5019.OUTA2
PELTIER-OUTB: PELTIER1.1, VNH5019.OUTB1, VNH5019.OUTB2
PELTIER-PWM: MICRO.D5, VNH5019.PWM
POST-OPTO-DIODE: K1.1, R1.2
RELAY-TO-MOTORCONTROLLER: K1.6, TLE5205.6
SCL: MICRO.D3, SDA__SCL1.2, SDA__SCL2.2
SDA: MICRO.D2, SDA__SCL1.1, SDA__SCL2.1
TEMPERATURE1: MICRO.A1, TEMPERATURE1.2
TEMPERATURE2: MICRO.A5, TEMPERATURE2.2
VIN: MICRO.VIN, VIN.1

## EAGLE design BoardMKI.brd

Parts:
D1, D2, D3: 1N4004; DO41-10
FAN: SMKDSP_1,5/2
IC1: TLE5205-2; P-TO220-7-11
K1, K2, K3: G5LE
MOTOR1: SMKDSP_1,5/2
PELTIER1: SMKDSP_1,5/2
PUMP: SMKDSP_1,5/2
R1, R2, R3, R4, R5, R6, R7, R8: R-US_0207/12; 0207/12
T1, T2, T3: 2N3704; TO92
U$1: ELECTRON_WITH_HEADERS; ELECTRON
U$2: VNH5019VNH5019BOARD; DIP3302W60P254L2400H500Q20B

Connections:
3V3: U$1.36 (3V3)
+12V: D1.C, D2.C, D3.C, K1.1, K1.S, K2.1, K2.S, K3.1, K3.S, U$2.VIN1, U$2.VIN2
C0: R8.1, U$1.19 (C0)
C1: R7.1, U$1.20 (C1)
C2: R2.1, U$1.21 (C2)
GND: FAN.2, IC1.4 (GND), PUMP.2, R3.1, R4.1, R6.1, T1.3 (E), T2.3 (E), T3.3 (E), U$1.2 (GND), U$1.33 (GND), U$2.GND1, U$2.GND2, U$2.GND3, U$2.GND4
unnamed: R1.2, R3.2, T1.1 (B)
unnamed: D1.A, K1.2, T1.2 (C)
unnamed: D2.A, K2.2, T2.2 (C)
unnamed: IC1.6 (VS), K2.P
unnamed: FAN.1, K1.P
unnamed: IC1.1 (OUT1), MOTOR1.1
unnamed: IC1.7 (OUT2), MOTOR1.2
unnamed: R2.2, R6.2, T2.1 (B)
unnamed: D3.A, K3.2, T3.2 (C)
unnamed: IC1.3 (IN1), R7.2
unnamed: K3.P, PUMP.1
unnamed: R4.2, R5.2, T3.1 (B)
unnamed: IC1.5 (IN2), R8.2
unnamed: PELTIER1.2, U$2.OUTB1, U$2.OUTB2
unnamed: PELTIER1.1, U$2.OUTA1, U$2.OUTA2
VBAT: U$1.34 (VBAT)
VIN: U$1.1 (VIN)

Board: 2 copper layers, 24 parts (0 on the bottom side), 20 nets, no tracks yet.

## EAGLE design PumpBlock.brd

Board: 2 copper layers, 160.0 x 100.0 mm, 12 parts (0 on the bottom side), 10 nets, no tracks yet.

Parts:
D1, D2: 1N4004; DO41-10
FAN: MSTBV2
K1, K2: G5LE
PUMP: MSTBV2
R1, R2, R3, R4: 0207/12
T1, T2: 2N3704; TO92

Connections:
+12V: K1.S, K2.S, R2.1, R4.1
GND: FAN.2, PUMP.2, T1.3, T2.3
unnamed: R1.2, T1.1
unnamed: D1.A, K1.2, T1.2
unnamed: D1.C, K1.1, R2.2
unnamed: D2.A, K2.2, T2.2
unnamed: K1.P, PUMP.1
unnamed: D2.C, K2.1, R4.2
unnamed: FAN.1, K2.P
unnamed: R3.2, T2.1

## Commit log

2018-09-13 Init
2018-09-13 ArduinoBaord MK1 Schematic Complete
2018-09-14 Arduino Board PCB Layout
2018-09-15 Updated PCB VIAS +more
2018-09-20 ElectornBoard PCB
2018-09-21 Net Lables + Pull-Down Resistors on Electron
2018-09-21 Holes
2018-09-21 Straightened Board
2018-09-21 DRC Fixes
2018-09-25 Audio
2018-09-25 Respacing
2018-09-27 Updated Parts
2018-09-27 Solid State Relay
2018-10-14 Display Board. Attained old board files. Schematic organization.
2018-10-16 Electron Board Changes
2018-11-02 Final Before Order
2018-11-07 MKII
2018-11-14 ArduinoBoardII Progress
2018-11-14 ElectronBoard MKII Progress LED
2018-11-15 Electron Progress
2018-11-15 More
2018-11-17 Arduino Side Headers
2018-11-18 Electron Side Header Start
2018-11-19 Progress!
2018-12-04 Buzzer Progress
2018-12-19 Updated Arduino wih correct grounding and board size.
