File: ArduinoBoardMK1.sch (EAGLE design)
At the start: 22 parts, among them K1 AQH2223

Commit message: MKII
Parts:
- R11, R6: value 47k -> 38k
